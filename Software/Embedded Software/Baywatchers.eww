<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Main Board\MainStateMachine.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Motion Board\RobotPid_O.ewp</path>
  </project>
  <batchBuild/>
</workspace>


