# IAR project MainStateMachine.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD_VL
  ICCARM.CCIncludePath2: ; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\DISCOVERY; ..\BaywatchersAPI\inc; ..\BaywatchersAPI\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.srec
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: Link\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Communication.c main_MainStateMachine.c stm32f10x_conf.h stm32f10x_it.c
  group BaywatchersAPI
    ../BaywatchersAPI/src/: EUROBOT_Init.c
  group CMSIS
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group DISCOVERY
    Libraries/DISCOVERY/: STM32vldiscovery.c
  group EWARMstartup
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md_vl.s
  group StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
